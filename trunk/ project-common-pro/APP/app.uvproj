# Keil uVision project app.uvproj, settings and files
target OTP_APP (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: app +hex
  AfterMake: .\copy.bat
  AfterMake: ..\link_hex\make.bat
  c flags: Optimize=9
  c include: .\lib;.\user;.\music_decode;.\ui;.\fm_receive;.\usb_device;..\link_hex;.\aux_fun;.\rtc_fun;.\decode_otp;.\fm_transmitter;.\codec;.\voice_time;.\kpl_msg
  asm include: .\lib;.\user;.\music_decode;.\ui;.\fm_receive;.\usb_device;..\link_hex;.\aux_fun;.\rtc_fun;.\fm_transmitter;.\codec;.\kpl_msg
  group lib
    ./lib/: STARTUP.A51 uart_page.c adc_page.c ap_emi_page.c cpu_page.c dac_amux_page.c iic_page.c io_page.c main_page.c spi_emi_dma_page.c spi_page.c timer_page.c power.c app.LIB
  group user
    ./user/: main.c uart.c filesystem.c device.c isr.a51
    ./ui/: key.c resource.c msgfor_hot.c my_IR_key.c Dsa.c
  group music_play
    ./ui/: eq.c
    ./music_decode/: mp3mode.c get_musice_file.c id3.c
    ./lib/: dac_vol.c
  group fm_receive
    ./fm_receive/: fm_receive.c fm_receive_api.c rda5807.c RDA_FM_drv.c Bk1080.c CL6017.c SP_3777_drv.c QN8035.c KT0830EG.c KT_AMFMdrv.c AR1019.c bk1088.c CL5767.c
  group usb_device
    ./usb_device/: msgfor_usb.c MANUFACTURE.a51
  group display
    ./ui/: disp.c lcd.c led.c disp_led.c led_drv.c disp_lcdsegment.c lcdsegment.c Display_Common.c lcd_ht1621_disp.c lcd_ht1621_drv.c lcd_tm1721_disp.c lcd_tm1721_drv.c led_1651.c
  group iic
    ./user/: iic_io.c iic_api.c
  group aun_fun
    ./aux_fun/: aux_fun.c ipone_ctrl.c bluetooth.c
  group RTC
    ./rtc_fun/: rtc_cpu.c rtc_fun.c rtc_mode.c
  group INFO
    ../link_hex/: info.txt
  group OTP_Play
    ./decode_otp/: decode_otp.c music_resource.c
  group fm_transmitter
    ./fm_transmitter/: BK1085.c
  group codec
    ./codec/: PT2313.c
  group voice_time
    ./voice_time/: voice_time.c voicetime_reource.c
  group kpl_msg
    ./kpl_msg/: kpl_msg.c
